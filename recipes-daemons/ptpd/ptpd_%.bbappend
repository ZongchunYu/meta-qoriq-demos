SRC_URI_qoriq = "https://github.com/qoriq-open-source/ptpd.git \
           file://ptpd-use-pkgconfig.patch \
           file://ptpd.service \
           file://ptpd.conf \
"
